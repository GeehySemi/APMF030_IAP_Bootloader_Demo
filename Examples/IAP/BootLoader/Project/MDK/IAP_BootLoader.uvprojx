# Keil uVision project IAP_BootLoader.uvprojx, settings and files
target APM32F030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F091VC Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IAP_BootLoader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F030_MINI,APM32F030x8
  c include: ..\..\..\..\..\Library\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Board;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
    ../../../../../Library/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f030.s startup_apm32f072.s
  group StdPeriphLib
    ../../../../../Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Board
    ../../../../../Board/: Board.c
  group Application
    ../../Source/: main.c apm32f0xx_int.c common.c menu.c ymodem.c
  group Bsp
    ../../Source/: bsp_flash.c bsp_usart.c
target APM32F072 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IWDT_FeedDog_Window
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F072_MINI,APM32F072xB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
